# Keil uVision project prj3633.uvproj, settings and files
target Master_UART1&UART2 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3633_app_master
  AfterMake: fromelf --bin --output .\output\app\bk3633_app_master.bin .\obj\bk3633_app_master.axf
  AfterMake: .\output\translate_master.bat
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CPU_BK3633,CLI_CONSOLE=1,
  c misc: --gnu
  c include: ..\..\src\ip\bt\api;..\..\src\ip\bt\import\reg;..\..\src\ip\bt\src;..\..\src\ip\em\api;.\src\ip\hci\api;.\src\ip\sch\api;..\..\src\ip\sch\import;..\..\src\modules\aes\api;..\..\src\modules\common\api;..\..\src\modules\dbg\api;..\..\src\modules\ecc_p256\api;..\..\src\modules\h4tl\api;..\..\src\modules\ke\api;.\src\modules\rf\api;..\..\src\modules\rwip;..\..\src\plf\rwip\import\reg;..\..\src\plf\refip\import\reg;..\..\src\plf\refip\src\arch;..\..\src\plf\refip\src\arch\boot\rvds;..\..\src\plf\refip\src\arch\compiler\rvds;..\..\src\plf\refip\src\arch\ll\rvds;..\..\src\driver\emi;..\..\src\driver\flash;..\..\src\driver\intc;..\..\src\driver\led;..\..\src\driver\reg;..\..\src\driver\syscntl;..\..\src\driver\timer;..\..\src\driver\uart;..\..\src\driver\uart2;..\..\Src\header;..\..\Src\header\header_file;..\..\src\driver;..\..\Src\ip\ble\hl\api;..\..\Src\ip\ble\hl\inc;..\..\Src\ip\ble\hl\src\gap\gapc;..\..\Src\ip\ble\hl\src\gap\gapm;..\..\Src\ip\ble\hl\src\gatt;..\..\Src\ip\ble\hl\src\gatt\attc;..\..\Src\ip\ble\hl\src\gatt\attm;..\..\Src\ip\ble\hl\src\gatt\atts;..\..\Src\ip\ble\hl\src\gatt\gattc;..\..\Src\ip\ble\hl\src\gatt\gattm;..\..\Src\ip\ble\hl\src\l2c\l2cc;..\..\Src\ip\ble\hl\src\l2c\l2cm;..\..\Src\ip\ble\ll\api;..\..\Src\ip\ble\ll\import\reg;..\..\Src\ip\ble\ll\src;..\..\Src\ip\ble\ll\llc;..\..\Src\ip\ble\ll\lld;..\..\Src\ip\ble\ll\llm;..\..\Src\app\api;..\..\Src\profiles\dis\diss\api;..\..\Src\profiles\FEE0\api;..\..\Src\profiles\bas\bass\api;..\..\Src\profiles\FCC0_128\api;..\..\src\driver\icu;..\..\src\driver\gpio;.\app\src\console;..\..\Src\profiles\electric\api;..\..\Src\profiles\sdp\api;..\..\Src\modules\ke\src;.\app\src;..\..\Src\ip\ble\ll\src\llm;..\..\src\driver\pwm;..\..\src\driver\wdt;..\..\Src\driver\adc;.\config;..\..\Src\ip\ble\ll\api;..\..\Src\ip\ble\ll\import\reg;..\..\Src\plf\rwip\api;..\..\Src\plf\prf;..\..\Src\driver;..\..\Src\driver\rf;..\..\Src\plf\nvds\api;.\app\api;..\..\Src\ip\em\api;..\..\Src\ip\hci\src;..\..\Src\ip\hci\api;..\..\Src\ip\sch\import;..\..\Src\ip\sch\api;..\boot\app;..\..\src\driver\usb;..\..\src\driver\usb\include;..\..\src\driver\usb\include\class;..\..\src\driver\usb\src\cd;..\..\src\driver\usb\src\drivers\comm;..\..\src\driver\usb\src\drivers\msd;..\..\src\driver\usb\src\examples;..\..\src\driver\usb\src\functions\trans_fn;..\..\src\driver\usb\src\systems\none;..\..\src\driver\usb\src\systems\none\afs;..\..\src\driver\usb\src\test;..\..\src\driver\usb\src\test\msd;..\..\src\driver\pwm;..\..\src\driver\timer0;..\..\Src\profiles\oad\api;.\app\user_func
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x400000 size 0x10000
  scatter file: ..\..\src\system\peripheral_app_link.txt
  link misc: --entry sys_Reset  --nodebug
  group Platform
    ./app/src/: main.c
    ../../Src/system/: target.c bk3633_initial.c boot_handlers.s boot_vectors.s peripheral_stack_symbol.txt
  group config
    ./config/: rwapp_config.h rwip_config.h rwprf_config.h user_config.h
  group bk_driver
    ../../Src/driver/rf/: rf_xvr.c
    ../../Src/driver/icu/: icu.c
    ../../Src/driver/: uart_initial.c uart1_initial.c
    ../../Src/driver/gpio/: gpio.c
    ./app/src/console/: cli_krhino.c cli_api.c
    ../../Src/driver/led/: led.c
    ../../Src/driver/intc/: intc.c
    ../../Src/driver/uart/: uart.c
    ../../Src/driver/flash/: flash.c
    ../../Src/driver/pwm/: pwm.c
    ../../Src/driver/timer/: timer.c
    ../../Src/driver/wdt/: wdt.c
    ../../Src/driver/adc/: adc.c
  group app
    ./app/src/: app.c app_adv.c app_scan.c app_init.c app_batt.c app_dis.c app_hid.c app_sec.c app_task.c app_fee0.c app_fcc0.c app_oads.c
    ../../Src/plf/nvds/src/: nvds.c
    ../../Src/driver/emi/: emi.c
    ../../Src/driver/syscntl/: syscntl.c
    ./app/Src/: arch_main.c
    ../../Src/plf/rwip/src/: rwip_driver.c
  group rw_profiles
    ../../Src/plf/prf/: prf_utils.c prf.c
    ../../Src/profiles/dis/diss/src/: diss.c diss_task.c
    ../../Src/profiles/FEE0/src/: fee0s.c fee0s_task.c
    ../../Src/profiles/bas/bass/src/: bass.c bass_task.c
    ../../Src/profiles/FCC0_128/src/: fcc0s.c fcc0s_task.c
    ../../Src/profiles/sdp/src/: sdp_service.c sdp_service_task.c
    ../../Src/profiles/oad/src/: oads.c oads_task.c
  group usb
    ../../Src/driver/usb/src/cd/: mu_cntlr.c mu_descs.c mu_drc.c mu_fc.c mu_fdr.c mu_fun.c mu_list.c mu_hst.c mu_pip.c
    ../../Src/driver/usb/src/examples/msd/: mu_msdfn.c
    ../../Src/driver/usb/src/systems/none/afs/: board.c
    ../../Src/driver/usb/src/test/msd/: tst_msd.c
    ../../Src/driver/usb/: driver_usb.c
    ../../Src/driver/usb/src/systems/none/: plat_uds.c
  group user_func
    ./app/user_func/: user_func.c
target Slave_USB&UART2 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3633_app_slave +hex
  AfterMake: fromelf --bin --output .\output\app\bk3633_app_slave.bin .\obj\bk3633_app_slave.axf
  AfterMake: .\output\translate_slave.bat
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CPU_BK3633,CLI_CONSOLE=1,USB_DRIVER=1,
  c misc: --gnu
  c include: as above
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x400000 size 0x10000
  scatter file: ..\..\src\system\peripheral_app_link.txt
  link misc: --entry sys_Reset  --nodebug
